## sdkconfig.defaults
```kconfig
CONFIG_AUTOSTART_ARDUINO=n
CONFIG_ESP_CONSOLE_UART_BAUDRATE=921600
CONFIG_FREERTOS_HZ=1000
```
